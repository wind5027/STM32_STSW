# IAR project Start_STM32F429_Discovery.ewp, settings and files
configuration Debug_JLink (ARM, debug)
  General.OGChipSelectEditMenu: STM32F4xxx ST STM32F4xxx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG=1; STM32F429_439xx; HSE_VALUE=8000000
  ICCARM.CCIncludePath2: Config; Inc; Setup; Setup\stlib; Setup\Common; Setup\DeviceSupport; OS; FS; GUI; USBH; Application; Application\SEGGERDEMO; Application\SEGGERDEMO\Src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Start_STM32F429_Discovery.srec
  ILINK.IlinkOutputFile: Start_STM32F429_Discovery.out
  ILINK.IlinkIcfFile: Setup\stm32f429_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release_JLink (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F429_439xx; HSE_VALUE=8000000
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
configuration Debug_STLink (ARM, debug)
  as the first configuration, except:
configuration Release_STLink (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F429_439xx; HSE_VALUE=8000000
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group (top)
    ./: ReadMe.txt
  group Application/Excluded
    Application/: FS_CheckDisk.c FS_DirOperations.c FS_Performance.c FS_PerformanceSimple.c FS_Start.c FS_STORAGE_DeviceActivity.c GUI_ALPHA_TransparentDialogDemo.c GUI_HelloWorld.c GUI_HouseControlDemo.c GUI_MEMDEV_ZoomAndRotate.c GUI_OS_Status.c GUI_RadialMenu.c GUI_ReversiDemo.c GUI_WIDGET_GraphXYDemo.c GUI_WIDGET_GraphYtDemo.c OS_Main_EVENT.c OS_Main_OS_Q.c OS_Main_TaskEx.c OS_MeasureCST_HRTimer_embOSView.c OS_MeasureCST_HRTimer_Printf.c OS_MeasureCST_Scope.c OS_PerformanceTest.c OS_Start_2Tasks.c OS_Start_LEDBlink.c OS_USBH_HID.c OS_USBH_MSD.c OS_USBH_Printer.c
  group Application/SEGGERDEMO
    Application/SEGGERDEMO/: SEGGERDEMO.c SEGGERDEMOv5_CM3_IAR_V6_7m_tlv_dp.a SEGGERDEMOv5_CM3_IAR_V6_7m_tlv_r.a
  group Application/SEGGERDEMO/Src
    Application/SEGGERDEMO/Src/: GUIDEMO.c GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c IMAGE_SeggerLogo_300x150_565c.c
  group Config
    Config/: FS_Conf.h FS_ConfigIO.c GUIConf.h SysConf.h USBH_ConfigIO.c
  group FS
    FS/: FS_7m_tlv_d_trial.a FS_7m_tlv_r_trial.a FS_X_embOS.c
  group GUI
    GUI/: GUI_X_embOS.c GUIv5_7m_tlv_d_trial.a GUIv5_7m_tlv_r_trial.a
  group OS
    OS/: Main.c os7m_tlv_dp_trial.a os7m_tlv_r_trial.a OS_Error.c
  group Setup
    Setup/: BSP.c FS_ConfigRAMDisk.c GUIConf.c LCDConf.c RTOSInit_STM32F4x_CMSIS.c stm32f429_flash.icf USBH_Config_STM32F2xx_HS_ST_F429Discovery.c
  group Setup/Common
    Setup/Common/: fonts.c
  group Setup/DeviceSupport
    Setup/DeviceSupport/: startup_stm32f429_439xx.s system_stm32f4xx.c
  group Setup/Excluded
    Setup/: FS_USBH_MSDConfig.c xmtx.c xmtx2.c
  group Setup/stlib
    Setup/stlib/: misc.c stm32f4xx_adc.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group USBH
    USBH/: USBH_7m_tlv_d_trial.a USBH_7m_tlv_r_trial.a
  group Util
    Util/: JLINKMEM_Process.c SEGGER_snprintf.c
